# Keil uVision project EPD.uvprojx, settings and files
target EPD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EPD +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD S110 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51
  c include: ..\config;..\EPD;..\components\toolchain;..\components\drivers_nrf\config;..\components\drivers_nrf\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\pstorage;..\components\drivers_nrf\pstorage\config;..\components\drivers_nrf\twi_master;..\components\libraries\trace;..\components\libraries\timer;..\components\libraries\util;..\components\ble\common;..\components\ble\ble_advertising;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s110\headers
  asm define: as above
  asm include: ..\components;..\components\drivers_nrf\common;..\components\libraries\log;..\components\libraries\log\src;..\components\drivers_nrf\hal;..\components\drivers_nrf\delay;..\components\drivers_nrf\nrf_soc_nosd;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\uart;..\components\libraries\util;..\components\toolchain;..\config;..\EPD;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x8000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group App
    ../: main.c
    ../config/: bsp.h nrf_drv_config.h pstorage_platform.h
  group EPD
    ../EPD/: DEV_Config.c EPD_4in2.c EPD_4in2_V2.c EPD_4in2b_V2.c EPD_2in13.c EPD_ble.c
  group nRF_BLE
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../components/libraries/util/: nrf_log.c nrf_assert.c app_error.c
    ../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group SEGGER_RTT
    ../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
target EPD_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: EPD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD S110 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51 DEBUG NRF_LOG_USES_RTT=1
  c include: ..\config;..\EPD;..\components\toolchain;..\components\drivers_nrf\config;..\components\drivers_nrf\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\pstorage;..\components\drivers_ext\segger_rtt;..\components\libraries\trace;..\components\libraries\timer;..\components\libraries\util;..\components\ble\common;..\components\ble\ble_advertising;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s110\headers
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x8000
  memory RVCT9: RAM 0x20002000 size 0x2000
target flash_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51
  c include: ..\config;..\EPD;..\GUI;..\components\toolchain;..\components\drivers_nrf\config;..\components\drivers_nrf\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\pstorage;..\components\libraries\log\src;..\components\libraries\log;..\components\libraries\trace;..\components\libraries\timer;..\components\libraries\util;..\components\ble\common;..\components\ble\ble_advertising;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s110\headers
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x8000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 4.3.0, Device:Startup 8.2.0, Device:Startup 8.44.1
